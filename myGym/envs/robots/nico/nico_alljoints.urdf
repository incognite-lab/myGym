Commit message: nico update

File: myGym/envs/robots/nico/nico_alljoints.urdf (robot description, URDF)
Before this commit: robot nico_upper_rh6d, 25 links, 24 joints
Links:
- link sight: geometry visual cylinder length=0.001 radius=0.001
