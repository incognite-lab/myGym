Commit message: undo concave=yes in urdfs of objects

File: myGym/envs/objects/assembly/urdf/simple.urdf (robot description, URDF)
Before this commit: robot cube_holes, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.06 0.06 0.06; visual box size=0.06 0.06 0.06
