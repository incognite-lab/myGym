Commit message: test script update - manual joint control

File: myGym/envs/objects/assembly/urdf/cube_holes_heavy.urdf (robot description, URDF)
Before this commit: robot cube_holes, 1 links, 0 joints
Links:
- link baseLink: mass 200.084 -> 10
