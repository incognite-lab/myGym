Commit message: new reward, vector moved to utils, new task style

File: myGym/envs/objects/assembly/urdf/poke_holes.urdf (robot description, URDF)
Before this commit: robot poke_holes, 1 links, 0 joints
Links:
- link baseLink: mass 10.084 -> 25.084
