Commit message: new mechanical gripper - panda_boxgripper

File: myGym/envs/objects/assembly/urdf/kostka.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- link box: geometry collision box size=.05 .05 .05; visual box size=.05 .05 .05
